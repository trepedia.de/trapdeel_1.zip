Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [modelReferenceView_V1.0]
File name: trapdeel 1.ifc
Time: 2025-09-30T11:23:57
Author: Raymond
Organization: Draw2design BV
Written by: IFCLib
Made in: TREPEDIA 4.0
Comment: stair
Comment: Wange 0-0
Comment: Wange 0-1
Comment: Wange 1-0
Comment: Wange 1-1
Comment: Stufe 1
Comment: Stufe 2
Comment: Stufe 3
Comment: Stufe 4
Comment: Stufe 5
Comment: Stufe 6
Comment: Stufe 7
Comment: Stufe 8
Comment: Stufe 9
Comment: Stufe 10
Comment: Stufe 11
Comment: upper ceiling
Comment: materials
Comment: end materials

# IfcProject, TREPEDIA Project
LongName: TREPEDIA Project; Phase: -

# IfcBuilding, Building
Description: Building; LongName: Building

# IfcPlate: - (16)
In: Building
Description: -
Name
Wange 0-0
Wange 0-1
Wange 1-0
Wange 1-1
Stufe 1
Stufe 2
Stufe 3
Stufe 4
Stufe 5
Stufe 6
Stufe 7
Stufe 8
Stufe 9
Stufe 10
Stufe 11
upper ceiling
